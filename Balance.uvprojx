# Keil uVision project Balance.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Balance +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\User\OLED;.\User\SYSTEM;.\User\MPU6050;.\User\HC_SR04;.\User\MOTOR;.\User\CONTROL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARUP
    ./Libraries/CMSIS/startup/: startup_stm32f10x_hd_vl.s
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h adc.c i2c.c exti.c
    ./User/OLED/: oled.c oledfont.c
    ./User/MPU6050/: MPU6050.c inv_mpu.c inv_mpu_dmp_motion_driver.c Kalman.c
    ./User/HC_SR04/: hc_sr.c
    ./User/MOTOR/: encoder.c motor.c
    ./User/CONTROL/: control.c show.c
  group DOC
    ./Doc/: readme.txt
  group SYS
    ./User/SYSTEM/: delay.c sys.c usart.c
